# Keil uVision project tjx_v1.1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: tjx_v1.1 +hex
  c flags: Optimize=9
  c define: STC89
  c include: ..\STC89_Lib\template;..\STC89_Lib\inc
  group LIBRARY
    ../STC89_Lib/src/: system.c nvic.c power.c wdt.c gpio.c exti.c timer.c uart.c mem.c isp.c soft_pwm.c soft_i2c.c soft_spi.c
  group DRIVER
    ./: keyboard.c 1602A.c
  group USER
    ./: STARTUP.A51 main.c
