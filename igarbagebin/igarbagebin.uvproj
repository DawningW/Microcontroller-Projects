# Keil uVision project igarbagebin.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5410AD STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x27FF) CLOCK(45000000)
  output: igarbagebin
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
