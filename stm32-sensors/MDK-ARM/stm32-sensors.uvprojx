# Keil uVision project stm32-sensors.uvprojx, settings and files
target stm32-sensors (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32-sensors +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,EMPL,EMPL_TARGET_STM32F4,MPU6500
  c include: ../Core/Inc;  ..\EMPL\driver\eMPL;  ..\EMPL\driver\include;  ..\EMPL\driver\stm32L;  ..\EMPL\eMPL-hal;  ..\EMPL\mllite;  ..\EMPL\mpl;  ..\Libraries\AHRS;  C:/Users/WC/STM32Cube/Repository/STM32Cube_FW_F4_V1.26.1/Drivers/STM32F4xx_HAL_Driver/Inc;  C:/Users/WC/STM32Cube/Repository/STM32Cube_FW_F4_V1.26.1/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  C:/Users/WC/STM32Cube/Repository/STM32Cube_FW_F4_V1.26.1/Drivers/CMSIS/Device/ST/STM32F4xx/Include;  C:/Users/WC/STM32Cube/Repository/STM32Cube_FW_F4_V1.26.1/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK-ARM
    ./: startup_stm32f407xx.s
  group Core
    ../Core/Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c main.c delay.c tim.c gpio.c i2c.c spi.c usart.c am2302.c hmc5883.c mpu9250.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/WC/STM32Cube/Repository/STM32Cube_FW_F4_V1.26.1/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/EMPL
    ../EMPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../EMPL/driver/stm32L/: log_stm32.c
    ../EMPL/eMPL-hal/: eMPL_outputs.c
    ../EMPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../EMPL/mpl/: libmpllib.lib
  group Libraries/AHRS
    ../Libraries/AHRS/: MahonyAHRS.c
software components: CMSIS:CORE 4.3.0
