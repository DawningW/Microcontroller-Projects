# Keil uVision project stm32f407-ucos3.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407-ucos3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__TARGET_FPU_SOFTVFP
  c include: ..\CMSIS;..\FWLIB\inc;..\UCOS\LIB;..\UCOS\LIB\Cfg;..\UCOS\CPU;..\UCOS\CPU\Cfg;..\UCOS\CPU\ARM-Cortex-M\ARMv7-M\ARM;..\UCOS\OS3\Cfg;..\UCOS\OS3\Source;..\UCOS\OS3\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\UCOS\BSP;..\USER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group UCOS/LIB
    ../UCOS/LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
    ../UCOS/LIB/: lib_mem.c lib_ascii.c lib_math.c lib_str.c
  group UCOS/CPU
    ../UCOS/CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
    ../UCOS/CPU/: cpu_core.c
    ../UCOS/CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../UCOS/CPU/Cache/ARM/armv7m_generic_l1/: cpu_cache_armv7m_generic_l1.c
  group UCOS/OS3
    ../UCOS/OS3/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../UCOS/OS3/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm
    ../UCOS/OS3/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../UCOS/OS3/Cfg/: os_app_hooks.c
  group UCOS/BSP
    ../UCOS/BSP/: bsp.c bsp_cpu.c bsp_os_dt.c
  group USER
    ./: startup_stm32f40_41xxx.s
    ../USER/: stm32f4xx_it.c app3.c usart.c
