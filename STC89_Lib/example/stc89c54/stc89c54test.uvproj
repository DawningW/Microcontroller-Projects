# Keil uVision project stc89c54test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: STC89
  c include: ..\..\inc
  group LIBRARY
    ../../src/: exti.c isp.c power.c timer.c uart.c gpio.c mem.c nvic.c soft_pwm.c system.c wdt.c
  group USER
    ./: STARTUP.A51 main.c
