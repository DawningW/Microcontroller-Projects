# Keil uVision project yuanmengbei.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: yuanmengbei +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\LIBRARIES;.\DRIVERS
  group LIBRARIES
    ./LIBRARIES/: ADC.c delay.c EEPROM.c Exti.c GPIO.c PCA.c Soft_UART.c timer.c USART.C
  group DRIVERS
    ./DRIVERS/: LCDTFT.c MKEY.c STEPMOTO.c LED.c
  group USER
    ./: STARTUP.A51 main.c
