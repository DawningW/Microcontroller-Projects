# Keil uVision project stc12c54.uvproj, settings and files
target 12C54 (MCS-51)
  device: STC12C5410AD STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x27FF) CLOCK(45000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 test.c
